# Keil uVision project lock_timer.uvprojx, settings and files
target STM32F103C8 10s Lock Timer (6180000::V6.18::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: lock_timer +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: D:\keli\pack\ARM\CMSIS\5.9.0\CMSIS\Core\Include;D:\keli\pack\Keil\STM32F1xx_DFP\2.4.1\Device\Include;D:\keli\pack\Keil\STM32F1xx_DFP\2.4.1\Device\StdPeriph_Driver\inc;.
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group 01_我的代码
    ./: lock_timer.c
  group 02_本座示例
    ../../_teacher/demo/05b_lock_timer/: lock_timer_demo.c
  group Startup
    ./Startup/: startup_stm32f10x_md.s
  group System
    ./System/: system_stm32f10x.c
  group Library
    ./Library/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_tim.c stm32f10x_exti.c
